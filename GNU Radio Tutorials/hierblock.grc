options:
  parameters:
    generate_options: qt_gui
    id: hierblock
    output_language: python
    title: hierblock
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    start: '-samp_rate/2'
    step: '1'
    stop: samp_rate/2
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: FrequencyShifter_0
  id: FrequencyShifter
  parameters:
    comment: |-
      A hier block is a user made block consisting of
      existing GNU blocks in a flow graph. Select the
      blocks you want in the hier block, right click, go
      to More, select Create Hier Block.
    freq: freq
    samp_rate: samp_rate
  states: {}
- name: analog_noise_source_x_1
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 8e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 4e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [FrequencyShifter_0, '0', blocks_throttle2_0, '0']
- [analog_noise_source_x_1, '0', low_pass_filter_1, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_1, '0', FrequencyShifter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
