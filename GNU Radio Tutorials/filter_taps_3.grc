options:
  parameters:
    generate_options: qt_gui
    id: low_pass_filter
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bandPassTaps
  id: variable
  parameters:
    value: lowPassTaps*freqShift
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: '-samp_rate/2'
    step: '1'
    stop: samp_rate/2
    value: '0'
  states: {}
- name: freqShift
  id: variable
  parameters:
    comment: |-
      Complex sin wave that has a freq
      of .25 the sampling rate.
    value: np.exp(2j*np.pi*.25*n)
  states: {}
- name: lowPassTaps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: samp_rate/4
    gain: '1.0'
    samp_rate: samp_rate
    width: samp_rate/8
    win: window.WIN_HAMMING
  states: {}
- name: n
  id: variable
  parameters:
    value: np.arange(0, len(lowPassTaps))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    comment: |-
      A complex filter will have different filter
      effects in the positive and negitive frequencies
    decim: '1'
    samp_rate: samp_rate
    taps: bandPassTaps
    type: fcc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
