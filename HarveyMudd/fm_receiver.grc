options:
  parameters:
    generate_options: qt_gui
    id: FM_RX
    output_language: python
    title: FM Receiver
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 80e6
    step: .2e6
    stop: 110e6
    value: 102.9e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.16e6
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
